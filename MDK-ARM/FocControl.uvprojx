# Keil uVision project FocControl.uvprojx, settings and files
target FocControl (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FocControl +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB,ARM_MATH_CM3
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../User/Hw;../User/Sw/fm;../User/Sw/fm/fm_user;../User/Sw/tms;../User/rte;../User/Sw/as;../Middlewares/Third_Party/ARM_CMSIS/PrivateInclude/;../Middlewares/Third_Party/ARM_CMSIS/Include/;../Middlewares/Third_Party/ARM_CMSIS/Include;../User;../User/Sw/mc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Sw/fm
    ../User/Sw/fm/: freemaster_appcmd.c freemaster_can.c freemaster_net.c freemaster_pdbdm.c freemaster_pipes.c freemaster_protocol.c freemaster_rec.c freemaster_scope.c freemaster_serial.c freemaster_sha.c freemaster_tsa.c freemaster_ures.c freemaster_utils.c freemaster.h freemaster_cfg.h
  group Sw/fm/user
    ../User/Sw/fm/fm_user/: freemaster_uart_user.c
  group User
    ../User/: udsp.h
  group Sw/rte
    ../User/Rte/: rte.c
  group Sw
    ../User/Sw/as/: as.c
    ../User/Sw/mc/: mc.c
    ../User/Sw/tms/: tms.c
  group Middlewares/CMSIS-DSP/CMSIS/DSP/Source
    ../Middlewares/Third_Party/ARM_CMSIS/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
    ../Middlewares/Third_Party/ARM_CMSIS/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../Middlewares/Third_Party/ARM_CMSIS/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
    ../Middlewares/Third_Party/ARM_CMSIS/Source/CommonTables/: CommonTables.c CommonTablesF16.c
    ../Middlewares/Third_Party/ARM_CMSIS/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
    ../Middlewares/Third_Party/ARM_CMSIS/Source/ControllerFunctions/: ControllerFunctions.c
    ../Middlewares/Third_Party/ARM_CMSIS/Source/DistanceFunctions/: DistanceFunctions.c DistanceFunctionsF16.c
    ../Middlewares/Third_Party/ARM_CMSIS/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
    ../Middlewares/Third_Party/ARM_CMSIS/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
    ../Middlewares/Third_Party/ARM_CMSIS/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
    ../Middlewares/Third_Party/ARM_CMSIS/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
    ../Middlewares/Third_Party/ARM_CMSIS/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
    ../Middlewares/Third_Party/ARM_CMSIS/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
    ../Middlewares/Third_Party/ARM_CMSIS/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
    ../Middlewares/Third_Party/ARM_CMSIS/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
    ../Middlewares/Third_Party/ARM_CMSIS/Source/WindowFunctions/: WindowFunctions.c
software components: CMSIS:CORE 5.6.0
